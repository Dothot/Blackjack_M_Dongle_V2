# Keil uVision project NWT.uvproj, settings and files
target NUC130VE3AN (ARM-ADS)
  device: NUC130VE3CN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: NWT
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Project
    ./: Project.c init.c startup_NUC1xx.s
  group Driver
    ../_Driver/: Driver_M_Dongle.c
  group Module
    ../_Module/: GLCD_NWT.c M_DONGLE_NWT.c
